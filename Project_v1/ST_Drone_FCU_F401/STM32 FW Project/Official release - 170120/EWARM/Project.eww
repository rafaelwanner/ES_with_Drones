<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STEVAL_FCU001V1_ver1.ewp</path>
  </project>
  <batchBuild />
</workspace>
